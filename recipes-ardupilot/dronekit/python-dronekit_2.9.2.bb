require dronekit_2.9.2.inc
inherit setuptools

R_DEPENDS = "python"