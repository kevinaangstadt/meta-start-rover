require dronekit_2.9.2.inc
inherit setuptools3

R_DEPENDS = "python3"