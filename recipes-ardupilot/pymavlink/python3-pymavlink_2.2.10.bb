require pymavlink_2.2.10.inc
inherit setuptools3

R_DEPENDS = "python3"