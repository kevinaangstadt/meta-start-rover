require pymavlink_2.2.10.inc
inherit setuptools

R_DEPENDS = "python"