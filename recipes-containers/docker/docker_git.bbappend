sRDEPENDS-${PN}_append += "kernel-module-xt-conntrack"

INITSCRIPT_PARAMS_${PN} = "defaults 90"
