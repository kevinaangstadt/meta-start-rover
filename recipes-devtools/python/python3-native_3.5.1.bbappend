FILESEXTRAPATHS_prepend := "${THISDIR}/python3:"

SRC_URI += "file://0001-Fix-for-library-path.patch"

